## conf/distro/hipos-cyber-security.conf
```bitbake
# HIPOS (HydraIP Operating System)

require conf/distro/hipos.conf

DISTRO = "hipos-cyber-security"

HYDRA_BUILD_TYPE ?= "devel"
```
